# Keil uVision project Mobile_Robot.uvprojx, settings and files
target TM4C123 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mobile_Robot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;.\UserLibraries
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c os.c osasm.s
  group UserLibraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    ./UserLibraries/: Algorithm.c BridgeH.c Encoder.c Profile.c UART.c HC_SRF.c
    ../../TM4C123Projects/OLED_SH1106/UserLibraries/: I2C.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
